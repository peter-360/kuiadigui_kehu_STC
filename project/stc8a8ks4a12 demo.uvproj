# Keil uVision project stc8a8ks4a12 demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8a8ks4a12 demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group Source Group 1
    ../user/: delay.c MAIN.C UART.C stc8aid.c IO.c timer.c adc.c pwm.c pca.c
